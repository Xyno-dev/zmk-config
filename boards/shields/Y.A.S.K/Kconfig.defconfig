## boards/shields/Y.A.S.K/Kconfig.defconfig
```kconfig
if SHIELD_YASK

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Y.A.S.K"

endif
```
